# IAR project demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105C6T6
  ICCSTM8.CCIncludePath2: ..\Library\inc; ..\User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.hex
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Library
    ../Library/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_tim2.c
  group User
    ../User/: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
